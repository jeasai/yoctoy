FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://hello.cfg file://0001-Add-a-simple-hello-world-char-driver.patch"
