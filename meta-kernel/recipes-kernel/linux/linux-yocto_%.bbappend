FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://defconfig file://0001-Add-a-simple-hello-world-char-driver.patch"
